# Keil uVision project lesson.uvprojx, settings and files
target dbg (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FPU_PRESENT
  c include: ..\KEIL_lib\core_CMSIS;..\KEIL_lib\TM4C1294NCPDT_sys
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --entry Reset_Handler
  group application
    ./: bsp.c main.c bsp.h
  group ek-tm4c1294
    ../KEIL_lib/TM4C1294NCPDT_sys/: startup_TM4C129.s
    ./: system_tm4c129.c
  group MiROS
    ./: miros.h miros.c
